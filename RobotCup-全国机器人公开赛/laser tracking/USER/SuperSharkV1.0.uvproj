# Keil uVision project SuperSharkV1.0.uvproj, settings and files
target 青锋机器人库存版 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SuperSharkV1.0 +hex
  c flags: Optim=1
  c include: ..\HARDWARE\BEEP;..\HARDWARE\DRIVER;..\HARDWARE\GETSENSOR;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD12864;..\HARDWARE\LED;..\HARDWARE\REMOTE;..\LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\track;..\arithmetic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group LIB
    ../LIB/: SuperSharkV1.0.lib
  group USER
    ./: stm32f10x_it.c main.c
  group track
    ../track/: track_jg.c track_jg.h track.c track.h track_bs.c
  group arithmetic
    ../arithmetic/: arithmetic.c
