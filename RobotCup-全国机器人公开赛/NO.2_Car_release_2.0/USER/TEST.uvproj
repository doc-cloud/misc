# Keil uVision project TEST.uvproj, settings and files
target 小车程序方案二 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TEST +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\OLED;..\HARDWARE\DRIVER;..\lib\inc;..\HARDWARE\BATTERY_AD;..\HARDWARE\BEEP;..\HARDWARE\GETSENSOR;..\HARDWARE\IIC;..\SYSTEM\user;..\USER;..\HARDWARE\DISTANCE;..\HARDWARE\COMPASS;..\Chinaword;..\englishword;..\LCD5110;..\track_jg;..\HARDWARE\COLOUR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group START
    ../start/: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ../lib/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_nvic.c
  group USER
    ./: test.c stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/user/: user.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DRIVER/: driver.c
    ../HARDWARE/GETSENSOR/: getsensor.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DISTANCE/: distance.c
    ../HARDWARE/COMPASS/: compass.c
    ../HARDWARE/COLOUR/: colour.c
  group LCD5110
    ../LCD5110/: lcd5110.c
  group TRACK_JG
    ../track_jg/: track_jg.c track_jg.h
